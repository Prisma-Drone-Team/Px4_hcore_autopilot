## src/examples/pitch_loop_ex/Kconfig
```kconfig
menuconfig EXAMPLES_PITCH_LOOP_EX
	bool "pitch_loop_ex"
	default n
	---help---
		Enable support for pitch_loop ex
```
